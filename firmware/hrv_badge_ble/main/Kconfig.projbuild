## firmware/hrv_badge_ble/main/Kconfig.projbuild
```kconfig
menu "HeartyPatch Configuration"

config BLE_MODE_ENABLE
	bool "Enable BLE mode"
	help
		Enable/Disable BLE mode

endmenu
```
